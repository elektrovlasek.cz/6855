Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-06-02T15:32:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 02 15:32:27 2020 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{AC49B434-65E7-4CFB-8528-EC3719E98A04}\ifc * Database version: 5507 * Database creation date: Tue Jun 02 15:32:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 02 15:32:27 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 02 15:32:27 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 30703020_D_11284550_ESW7030_OBSW, 11284550_D_ESW7030_OBSW:30703020_D_11284550_ESW7030_OBSW:204016
In: Level 1
Type - Classification: ESW7000 (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 30703020_D_11284550_ESW7030_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
